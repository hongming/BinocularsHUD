# Keil uVision project GYXX_USART.uvprojx, settings and files
target GYXX_USART (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GYXX_USART +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Peripherals\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib_CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Lib_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c
  group Peripherals
    ../Peripherals/src/: usart.c stm32f10x_it.c LED.c delay.c
  group user
    ./: main.c
software components: CMSIS:CORE 4.3.0
